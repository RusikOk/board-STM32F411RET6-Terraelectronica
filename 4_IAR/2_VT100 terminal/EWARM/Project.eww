<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\2021-02-09 Okopny.ewp</path>
  </project>
  <batchBuild />
</workspace>
