<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\BOARD_STM32F411RE.ewp</path>
  </project>
  <batchBuild />
</workspace>
